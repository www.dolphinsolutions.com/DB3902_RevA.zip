Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DB3902_RevA.IFC
Time: 2020-05-28T13:37:53
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: DB3002_BIM
In: Default Storey
Material: Steel
